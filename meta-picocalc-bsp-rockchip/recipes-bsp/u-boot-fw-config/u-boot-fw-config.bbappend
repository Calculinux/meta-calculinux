# Luckfox Lyra keeps the U-Boot environment in the GPT "ubootenv" partition.
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
