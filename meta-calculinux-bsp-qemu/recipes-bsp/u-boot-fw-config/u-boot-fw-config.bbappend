# QEMU virt keeps the U-Boot environment in the second pflash bank.
FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
