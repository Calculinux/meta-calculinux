FILESEXTRAPATHS:prepend:calculinux-qemuarm := "${THISDIR}/files:"

SRC_URI:append:calculinux-qemuarm = " file://calculinux.cfg"
