require hoard-of-bitfonts.inc

SUMMARY = "Amiga fonts from Hoard of Bitfonts"
DESCRIPTION = "Commodore Amiga fonts from Workbench and various Amiga applications. \
Includes classic Topaz and other iconic Amiga typefaces from the 1980s-1990s."

FONT_COLLECTION = "amiga"

RPROVIDES:${PN} = "hoard-of-bitfonts-amiga"
