require hoard-of-bitfonts.inc

SUMMARY = "Banner fonts from Hoard of Bitfonts"
DESCRIPTION = "Banner and ASCII art fonts for large-format text displays."

FONT_COLLECTION = "banner"

RPROVIDES:${PN} = "hoard-of-bitfonts-banner"
