require hoard-of-bitfonts.inc

SUMMARY = "Atari fonts from Hoard of Bitfonts"
DESCRIPTION = "Atari ST, STe, TT, and Falcon system fonts. Includes fonts from \
GEM Desktop, TOS, and various Atari applications."

FONT_COLLECTION = "atari"

RPROVIDES:${PN} = "hoard-of-bitfonts-atari"
