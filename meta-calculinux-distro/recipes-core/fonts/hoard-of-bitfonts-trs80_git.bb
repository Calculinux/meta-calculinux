require hoard-of-bitfonts.inc

SUMMARY = "TRS-80 fonts from Hoard of Bitfonts"
DESCRIPTION = "Tandy Radio Shack TRS-80 Model I, II, III, 4, and compatible system fonts."

FONT_COLLECTION = "trs-80"

RPROVIDES:${PN} = "hoard-of-bitfonts-trs80"
