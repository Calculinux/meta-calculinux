require hoard-of-bitfonts.inc

SUMMARY = "RK-86 fonts from Hoard of Bitfonts"
DESCRIPTION = "RK-86 Soviet computer system fonts."

FONT_COLLECTION = "rk-86"

RPROVIDES:${PN} = "hoard-of-bitfonts-rk86"
