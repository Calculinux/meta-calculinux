require hoard-of-bitfonts.inc

SUMMARY = "Windows fonts from Hoard of Bitfonts"
DESCRIPTION = "Early Microsoft Windows bitmap fonts from Windows 1.0, 2.0, 3.x, and \
early Windows 9x. Includes classic system fonts before TrueType became standard."

FONT_COLLECTION = "windows"

RPROVIDES:${PN} = "hoard-of-bitfonts-windows"
