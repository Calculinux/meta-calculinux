require hoard-of-bitfonts.inc

SUMMARY = "Amstrad fonts from Hoard of Bitfonts"
DESCRIPTION = "Amstrad CPC, PCW, and other Amstrad system fonts."

FONT_COLLECTION = "amstrad"

RPROVIDES:${PN} = "hoard-of-bitfonts-amstrad"
