require hoard-of-bitfonts.inc

SUMMARY = "GEOS fonts from Hoard of Bitfonts"
DESCRIPTION = "GEOS operating system fonts for Commodore and other platforms."

FONT_COLLECTION = "geos"

RPROVIDES:${PN} = "hoard-of-bitfonts-geos"
