require hoard-of-bitfonts.inc

SUMMARY = "Sharp fonts from Hoard of Bitfonts"
DESCRIPTION = "Sharp computer system fonts including X68000 and other models."

FONT_COLLECTION = "sharp"

RPROVIDES:${PN} = "hoard-of-bitfonts-sharp"
