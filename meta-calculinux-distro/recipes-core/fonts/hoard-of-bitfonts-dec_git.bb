require hoard-of-bitfonts.inc

SUMMARY = "DEC fonts from Hoard of Bitfonts"
DESCRIPTION = "Digital Equipment Corporation (DEC) VT series terminal fonts. \
Includes VT100, VT220, VT320 and other classic DEC terminal fonts."

FONT_COLLECTION = "dec"

RPROVIDES:${PN} = "hoard-of-bitfonts-dec"
