require hoard-of-bitfonts.inc

SUMMARY = "NCR7250 fonts from Hoard of Bitfonts"
DESCRIPTION = "NCR 7250 terminal system fonts."

FONT_COLLECTION = "ncr7250"

RPROVIDES:${PN} = "hoard-of-bitfonts-ncr7250"
