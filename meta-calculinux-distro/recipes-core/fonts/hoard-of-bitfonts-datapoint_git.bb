require hoard-of-bitfonts.inc

SUMMARY = "Datapoint fonts from Hoard of Bitfonts"
DESCRIPTION = "Datapoint terminal and computer system fonts."

FONT_COLLECTION = "datapoint"

RPROVIDES:${PN} = "hoard-of-bitfonts-datapoint"
