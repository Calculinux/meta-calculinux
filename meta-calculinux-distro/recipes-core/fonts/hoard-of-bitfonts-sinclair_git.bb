require hoard-of-bitfonts.inc

SUMMARY = "Sinclair fonts from Hoard of Bitfonts"
DESCRIPTION = "Sinclair ZX Spectrum, ZX80, ZX81, and QL system fonts. Includes \
classic British home computer fonts from the 1980s."

FONT_COLLECTION = "sinclair"

RPROVIDES:${PN} = "hoard-of-bitfonts-sinclair"
