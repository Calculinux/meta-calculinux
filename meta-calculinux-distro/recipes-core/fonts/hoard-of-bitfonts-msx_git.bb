require hoard-of-bitfonts.inc

SUMMARY = "MSX fonts from Hoard of Bitfonts"
DESCRIPTION = "MSX, MSX2, MSX2+, and MSX turboR system fonts. Includes fonts from \
various MSX computers and applications."

FONT_COLLECTION = "msx"

RPROVIDES:${PN} = "hoard-of-bitfonts-msx"
