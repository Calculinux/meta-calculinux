require hoard-of-bitfonts.inc

SUMMARY = "Kyotronic fonts from Hoard of Bitfonts"
DESCRIPTION = "Kyotronic computer system fonts."

FONT_COLLECTION = "kyotronic"

RPROVIDES:${PN} = "hoard-of-bitfonts-kyotronic"
