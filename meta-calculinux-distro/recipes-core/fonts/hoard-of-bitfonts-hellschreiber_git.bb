require hoard-of-bitfonts.inc

SUMMARY = "Hellschreiber fonts from Hoard of Bitfonts"
DESCRIPTION = "Hellschreiber teleprinter fonts, historical telecommunications fonts."

FONT_COLLECTION = "hellschreiber"

RPROVIDES:${PN} = "hoard-of-bitfonts-hellschreiber"
