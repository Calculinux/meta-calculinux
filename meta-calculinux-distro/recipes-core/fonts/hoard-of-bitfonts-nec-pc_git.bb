require hoard-of-bitfonts.inc

SUMMARY = "NEC PC fonts from Hoard of Bitfonts"
DESCRIPTION = "NEC PC-98 and other NEC computer system fonts. PC-98 was hugely \
popular in Japan during the 1980s-1990s."

FONT_COLLECTION = "nec-pc"

RPROVIDES:${PN} = "hoard-of-bitfonts-nec-pc"
