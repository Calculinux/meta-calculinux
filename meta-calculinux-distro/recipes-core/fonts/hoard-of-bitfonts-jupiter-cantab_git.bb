require hoard-of-bitfonts.inc

SUMMARY = "Jupiter Cantab fonts from Hoard of Bitfonts"
DESCRIPTION = "Jupiter Cantab computer system fonts."

FONT_COLLECTION = "jupiter_cantab"

RPROVIDES:${PN} = "hoard-of-bitfonts-jupiter-cantab"
