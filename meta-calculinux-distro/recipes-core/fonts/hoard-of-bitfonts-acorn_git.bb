require hoard-of-bitfonts.inc

SUMMARY = "Acorn fonts from Hoard of Bitfonts"
DESCRIPTION = "Acorn Computers fonts from BBC Micro, Electron, Archimedes, and RISC OS systems."

FONT_COLLECTION = "acorn"

RPROVIDES:${PN} = "hoard-of-bitfonts-acorn"
