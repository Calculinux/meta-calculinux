require hoard-of-bitfonts.inc

SUMMARY = "PC fonts from Hoard of Bitfonts"
DESCRIPTION = "IBM PC/XT/AT, CGA, EGA, VGA, MDA, and compatible system fonts. \
Includes fonts from DOS, OS/2, early Windows, and PC BIOS character sets."

FONT_COLLECTION = "pc"

RPROVIDES:${PN} = "hoard-of-bitfonts-pc"
