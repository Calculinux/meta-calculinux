require hoard-of-bitfonts.inc

SUMMARY = "CRT8002 fonts from Hoard of Bitfonts"
DESCRIPTION = "CRT8002 terminal system fonts."

FONT_COLLECTION = "crt8002"

RPROVIDES:${PN} = "hoard-of-bitfonts-crt8002"
