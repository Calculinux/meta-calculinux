require hoard-of-bitfonts.inc

SUMMARY = "NeXT fonts from Hoard of Bitfonts"
DESCRIPTION = "NeXT Computer and NeXTSTEP system fonts with iconic typography."

FONT_COLLECTION = "next"

RPROVIDES:${PN} = "hoard-of-bitfonts-next"
