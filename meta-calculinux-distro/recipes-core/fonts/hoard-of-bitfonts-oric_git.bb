require hoard-of-bitfonts.inc

SUMMARY = "Oric fonts from Hoard of Bitfonts"
DESCRIPTION = "Oric-1 and Oric Atmos computer system fonts."

FONT_COLLECTION = "oric"

RPROVIDES:${PN} = "hoard-of-bitfonts-oric"
