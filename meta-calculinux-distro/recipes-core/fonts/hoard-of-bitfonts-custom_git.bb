require hoard-of-bitfonts.inc

SUMMARY = "Custom fonts from Hoard of Bitfonts"
DESCRIPTION = "Custom and user-contributed bitmap fonts."

FONT_COLLECTION = "|custom|"

RPROVIDES:${PN} = "hoard-of-bitfonts-custom"
