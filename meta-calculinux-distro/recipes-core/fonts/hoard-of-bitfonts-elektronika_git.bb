require hoard-of-bitfonts.inc

SUMMARY = "Elektronika fonts from Hoard of Bitfonts"
DESCRIPTION = "Soviet Elektronika computer system fonts."

FONT_COLLECTION = "elektronika"

RPROVIDES:${PN} = "hoard-of-bitfonts-elektronika"
