require hoard-of-bitfonts.inc

SUMMARY = "Various fonts from Hoard of Bitfonts"
DESCRIPTION = "Miscellaneous and uncategorized bitmap fonts from various systems."

FONT_COLLECTION = "various"

RPROVIDES:${PN} = "hoard-of-bitfonts-various"
