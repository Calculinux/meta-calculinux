require hoard-of-bitfonts.inc

SUMMARY = "PC/GEOS fonts from Hoard of Bitfonts"
DESCRIPTION = "PC/GEOS graphical operating system fonts."

FONT_COLLECTION = "pc-geos"

RPROVIDES:${PN} = "hoard-of-bitfonts-pc-geos"
