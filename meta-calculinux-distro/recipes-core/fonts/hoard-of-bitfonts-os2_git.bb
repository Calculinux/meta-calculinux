require hoard-of-bitfonts.inc

SUMMARY = "OS/2 fonts from Hoard of Bitfonts"
DESCRIPTION = "IBM OS/2 operating system fonts from various OS/2 versions."

FONT_COLLECTION = "os-2"

RPROVIDES:${PN} = "hoard-of-bitfonts-os2"
