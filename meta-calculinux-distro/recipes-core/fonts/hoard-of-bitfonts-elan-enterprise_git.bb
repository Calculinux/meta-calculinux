require hoard-of-bitfonts.inc

SUMMARY = "Elan Enterprise fonts from Hoard of Bitfonts"
DESCRIPTION = "Elan Enterprise computer system fonts."

FONT_COLLECTION = "elan_enterprise"

RPROVIDES:${PN} = "hoard-of-bitfonts-elan-enterprise"
