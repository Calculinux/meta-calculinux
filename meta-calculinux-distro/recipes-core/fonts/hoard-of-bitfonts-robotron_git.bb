require hoard-of-bitfonts.inc

SUMMARY = "Robotron fonts from Hoard of Bitfonts"
DESCRIPTION = "Robotron computer system fonts from East Germany."

FONT_COLLECTION = "robotron"

RPROVIDES:${PN} = "hoard-of-bitfonts-robotron"
