require hoard-of-bitfonts.inc

SUMMARY = "GEM fonts from Hoard of Bitfonts"
DESCRIPTION = "GEM Desktop Environment fonts from Digital Research."

FONT_COLLECTION = "gem"

RPROVIDES:${PN} = "hoard-of-bitfonts-gem"
