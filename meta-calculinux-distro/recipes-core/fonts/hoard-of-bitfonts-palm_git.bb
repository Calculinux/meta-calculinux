require hoard-of-bitfonts.inc

SUMMARY = "Palm fonts from Hoard of Bitfonts"
DESCRIPTION = "Palm OS PDA system fonts from Palm Pilot and related devices."

FONT_COLLECTION = "palm"

RPROVIDES:${PN} = "hoard-of-bitfonts-palm"
