require hoard-of-bitfonts.inc

SUMMARY = "HP fonts from Hoard of Bitfonts"
DESCRIPTION = "Hewlett-Packard terminal, computer, and calculator fonts."

FONT_COLLECTION = "hp"

RPROVIDES:${PN} = "hoard-of-bitfonts-hp"
