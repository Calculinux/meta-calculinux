require hoard-of-bitfonts.inc

SUMMARY = "Apple fonts from Hoard of Bitfonts"
DESCRIPTION = "Apple II, IIe, IIc, IIgs, and early Macintosh bitmap fonts. \
Includes classic Apple system fonts from the 1980s."

FONT_COLLECTION = "apple"

RPROVIDES:${PN} = "hoard-of-bitfonts-apple"
