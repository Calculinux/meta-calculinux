require hoard-of-bitfonts.inc

SUMMARY = "Fujitsu fonts from Hoard of Bitfonts"
DESCRIPTION = "Fujitsu computer and terminal system fonts."

FONT_COLLECTION = "fujitsu"

RPROVIDES:${PN} = "hoard-of-bitfonts-fujitsu"
