require hoard-of-bitfonts.inc

SUMMARY = "Commodore fonts from Hoard of Bitfonts"
DESCRIPTION = "Commodore 64, 128, VIC-20, Plus/4, and PET system fonts. Includes \
the iconic PETSCII character sets and Commodore 8-bit computer fonts."

FONT_COLLECTION = "commodore"

RPROVIDES:${PN} = "hoard-of-bitfonts-commodore"
