require hoard-of-bitfonts.inc

SUMMARY = "Xerox fonts from Hoard of Bitfonts"
DESCRIPTION = "Xerox system fonts including Alto and Star workstations."

FONT_COLLECTION = "xerox"

RPROVIDES:${PN} = "hoard-of-bitfonts-xerox"
