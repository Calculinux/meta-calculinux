require hoard-of-bitfonts.inc

SUMMARY = "Texas Instruments fonts from Hoard of Bitfonts"
DESCRIPTION = "Texas Instruments computer fonts including TI-99/4A and other models."

FONT_COLLECTION = "texas_instruments"

RPROVIDES:${PN} = "hoard-of-bitfonts-texas-instruments"
