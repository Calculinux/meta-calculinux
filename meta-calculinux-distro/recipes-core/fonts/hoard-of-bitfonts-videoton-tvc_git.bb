require hoard-of-bitfonts.inc

SUMMARY = "Videoton TVC fonts from Hoard of Bitfonts"
DESCRIPTION = "Videoton TVC computer system fonts from Hungary."

FONT_COLLECTION = "videoton_tvc"

RPROVIDES:${PN} = "hoard-of-bitfonts-videoton-tvc"
