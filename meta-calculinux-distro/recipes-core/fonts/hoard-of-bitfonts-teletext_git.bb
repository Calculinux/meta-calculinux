require hoard-of-bitfonts.inc

SUMMARY = "Teletext fonts from Hoard of Bitfonts"
DESCRIPTION = "Teletext broadcast system fonts with unique mosaic and character sets."

FONT_COLLECTION = "teletext"

RPROVIDES:${PN} = "hoard-of-bitfonts-teletext"
