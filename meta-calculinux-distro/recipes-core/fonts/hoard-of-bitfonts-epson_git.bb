require hoard-of-bitfonts.inc

SUMMARY = "Epson fonts from Hoard of Bitfonts"
DESCRIPTION = "Epson printer and computer system fonts."

FONT_COLLECTION = "epson"

RPROVIDES:${PN} = "hoard-of-bitfonts-epson"
