FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-include-mount-api-utils.h-fix-LSMT_ROOT-definition.patch"
