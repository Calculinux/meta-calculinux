EXTRA_OECONF += "no-asm no-hw no-afalgeng"
