require ${COREBASE}/meta/classes-recipe/compress_doc.bbclass
